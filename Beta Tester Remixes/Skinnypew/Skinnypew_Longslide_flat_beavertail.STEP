STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION (( 'STEP AP203' ), '1' );
FILE_NAME ('Longslide_no_beavertale.STEP', '2021-05-30T00:43:13', ( '' ), ( '' ), 'SwSTEP 2.0', 'SolidWorks 2020', '' );
FILE_SCHEMA (( 'CONFIG_CONTROL_DESIGN' ));
Length unit declared in the file: millimetre
Products named in the file (1): Longslide_no_beavertale
Bounding box: 210.6 x 110.97 x 29 mm (x, y, z)
Volume: 90749.3 mm3; surface area: 51536.8 mm2
Topology: 5 solids, 5 shells, 576 faces, 1622 edges, 1042 vertices
Faces by surface type: plane 297, cylinder 197, bspline 38, torus 36, cone 6, sphere 2
Entity records: 20209 total; most frequent: CARTESIAN_POINT 5931, ORIENTED_EDGE 3236, DIRECTION 2668, EDGE_CURVE 1618, VERTEX_POINT 1042, VECTOR 1010, LINE 1010, AXIS2_PLACEMENT_3D 829
