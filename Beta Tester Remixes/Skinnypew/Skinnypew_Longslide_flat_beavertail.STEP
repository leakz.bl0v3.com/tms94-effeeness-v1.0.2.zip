One B-rep face of a CAD part: STEP entity #10770.
In plain terms, the cylindrical face has radius 12.5 mm (diameter 25 mm), a partial arc.
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#1445 = CARTESIAN_POINT ( 'NONE',  ( -58.418, 28.756, -30.339 ) ) ;
#2373 = DIRECTION ( 'NONE',  ( -0.309, -0.951, 0. ) ) ;
#2794 = LINE ( 'NONE', #4325, #8954 ) ;
#3321 = VERTEX_POINT ( 'NONE', #8539 ) ;
#3611 = CARTESIAN_POINT ( 'NONE',  ( -77.94, -19.479, -24.86 ) ) ;
#4325 = CARTESIAN_POINT ( 'NONE',  ( -61.9, 29.887, -21.5 ) ) ;
#6770 = VERTEX_POINT ( 'NONE', #14533 ) ;
#6986 = FACE_OUTER_BOUND ( 'NONE', #19910, .T. ) ;
#7910 = CIRCLE ( 'NONE', #19442, 12.5 ) ;
#8539 = CARTESIAN_POINT ( 'NONE',  ( -77.94, -19.479, -21.5 ) ) ;
#8633 = DIRECTION ( 'NONE',  ( -0.672, 0.219, -0.707 ) ) ;
#8954 = VECTOR ( 'NONE', #10388, 1000. ) ;
#9843 = CARTESIAN_POINT ( 'NONE',  ( -62.54, 16.069, -30.339 ) ) ;
#9900 = VERTEX_POINT ( 'NONE', #9843 ) ;
#10388 = DIRECTION ( 'NONE',  ( 0.309, 0.951, 0. ) ) ;
#10770 = ADVANCED_FACE ( 'NONE', ( #6986 ), #16469, .T. ) ;
#11166 = EDGE_CURVE ( 'NONE', #15879, #9900, #7910, .T. ) ;
#11610 = ORIENTED_EDGE ( 'NONE', *, *, #16452, .T. ) ;
#12399 = CARTESIAN_POINT ( 'NONE',  ( -66.022, 17.2, -21.5 ) ) ;
#12933 = CARTESIAN_POINT ( 'NONE',  ( -54.134, 13.337, -21.5 ) ) ;
#12969 = CARTESIAN_POINT ( 'NONE',  ( -76.588, -19.479, -27.963 ) ) ;
#14490 = AXIS2_PLACEMENT_3D ( 'NONE', #19346, #2373, #8633 ) ;
#14533 = CARTESIAN_POINT ( 'NONE',  ( -74.091, -19.479, -30.339 ) ) ;
#15469 = ORIENTED_EDGE ( 'NONE', *, *, #19156, .T. ) ;
#15522 = LINE ( 'NONE', #1445, #17660 ) ;
#15625 =( BOUNDED_CURVE ( )  B_SPLINE_CURVE ( 3, ( #17232, #3611, #12969, #20213 ),
 .UNSPECIFIED., .F., .F. ) 
 B_SPLINE_CURVE_WITH_KNOTS ( ( 4, 4 ),
 ( 0., 0.785 ),
 .UNSPECIFIED. ) 
 CURVE ( )  GEOMETRIC_REPRESENTATION_ITEM ( )  RATIONAL_B_SPLINE_CURVE ( ( 1., 0.949, 0.949, 1. ) ) 
 REPRESENTATION_ITEM ( '' )  );
#15879 = VERTEX_POINT ( 'NONE', #12399 ) ;
#16379 = ORIENTED_EDGE ( 'NONE', *, *, #11166, .T. ) ;
#16452 = EDGE_CURVE ( 'NONE', #3321, #15879, #2794, .T. ) ;
#16469 = CYLINDRICAL_SURFACE ( 'NONE', #14490, 12.5 ) ;
#16849 = DIRECTION ( 'NONE',  ( -0.951, 0.309, 0. ) ) ;
#17227 = ORIENTED_EDGE ( 'NONE', *, *, #19957, .F. ) ;
#17232 = CARTESIAN_POINT ( 'NONE',  ( -77.94, -19.479, -21.5 ) ) ;
#17660 = VECTOR ( 'NONE', #18318, 1000. ) ;
#18318 = DIRECTION ( 'NONE',  ( -0.309, -0.951, 0. ) ) ;
#19156 = EDGE_CURVE ( 'NONE', #9900, #6770, #15522, .T. ) ;
#19215 = DIRECTION ( 'NONE',  ( -0.309, -0.951, 0. ) ) ;
#19346 = CARTESIAN_POINT ( 'NONE',  ( -50.012, 26.025, -21.5 ) ) ;
#19442 = AXIS2_PLACEMENT_3D ( 'NONE', #12933, #19215, #16849 ) ;
#19910 = EDGE_LOOP ( 'NONE', ( #16379, #15469, #17227, #11610 ) ) ;
#19957 = EDGE_CURVE ( 'NONE', #3321, #6770, #15625, .T. ) ;
#20213 = CARTESIAN_POINT ( 'NONE',  ( -74.091, -19.479, -30.339 ) ) ;
