One B-rep face of a CAD part: STEP entity #20.
In plain terms, the free-form (B-spline) face has degree [1, 2] with [2, 3] control points.
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#20=ADVANCED_FACE('',(#31),#363,.T.);
#31=FACE_OUTER_BOUND('',#42,.T.);
#42=EDGE_LOOP('',(#77,#78,#79,#80));
#77=ORIENTED_EDGE('',*,*,#302,.T.);
#78=ORIENTED_EDGE('',*,*,#290,.F.);
#79=ORIENTED_EDGE('',*,*,#300,.F.);
#80=ORIENTED_EDGE('',*,*,#303,.T.);
#110=PCURVE('',#369,#164);
#125=PCURVE('',#368,#179);
#131=PCURVE('',#363,#185);
#132=PCURVE('',#363,#186);
#133=PCURVE('',#363,#187);
#134=PCURVE('',#363,#188);
#136=PCURVE('',#367,#190);
#148=PCURVE('',#370,#202);
#164=DEFINITIONAL_REPRESENTATION('',(#319),#763);
#179=DEFINITIONAL_REPRESENTATION('',(#329),#763);
#185=DEFINITIONAL_REPRESENTATION('',(#236),#763);
#186=DEFINITIONAL_REPRESENTATION('',(#237),#763);
#187=DEFINITIONAL_REPRESENTATION('',(#238),#763);
#188=DEFINITIONAL_REPRESENTATION('',(#239),#763);
#190=DEFINITIONAL_REPRESENTATION('',(#334),#763);
#202=DEFINITIONAL_REPRESENTATION('',(#341),#763);
#236=B_SPLINE_CURVE_WITH_KNOTS('',1,(#693,#694),.UNSPECIFIED.,.F.,.F.,(2,
2),(-16.,-3.),.UNSPECIFIED.);
#237=B_SPLINE_CURVE_WITH_KNOTS('',1,(#695,#696),.UNSPECIFIED.,.F.,.F.,(2,
2),(0.,4.594),.UNSPECIFIED.);
#238=B_SPLINE_CURVE_WITH_KNOTS('',1,(#697,#698),.UNSPECIFIED.,.F.,.F.,(2,
2),(-16.,-3.),.UNSPECIFIED.);
#239=B_SPLINE_CURVE_WITH_KNOTS('',1,(#702,#703),.UNSPECIFIED.,.F.,.F.,(2,
2),(0.,4.594),.UNSPECIFIED.);
#263=SURFACE_CURVE('',#318,(#110,#132),.PCURVE_S1.);
#273=SURFACE_CURVE('',#328,(#125,#133),.PCURVE_S1.);
#275=SURFACE_CURVE('',#332,(#131,#148),.PCURVE_S1.);
#276=SURFACE_CURVE('',#333,(#134,#136),.PCURVE_S1.);
#290=EDGE_CURVE('',#356,#357,#263,.T.);
#300=EDGE_CURVE('',#355,#356,#273,.T.);
#302=EDGE_CURVE('',#354,#357,#275,.T.);
#303=EDGE_CURVE('',#355,#354,#276,.T.);
#318=(
BOUNDED_CURVE()
B_SPLINE_CURVE(2,(#615,#616,#617),.UNSPECIFIED.,.F.,.F.)
B_SPLINE_CURVE_WITH_KNOTS((3,3),(0.,4.594),.UNSPECIFIED.)
CURVE()
GEOMETRIC_REPRESENTATION_ITEM()
RATIONAL_B_SPLINE_CURVE((1.,0.988,1.))
REPRESENTATION_ITEM('')
);
#319=(
BOUNDED_CURVE()
B_SPLINE_CURVE(2,(#618,#619,#620),.UNSPECIFIED.,.F.,.F.)
B_SPLINE_CURVE_WITH_KNOTS((3,3),(0.,4.594),.UNSPECIFIED.)
CURVE()
GEOMETRIC_REPRESENTATION_ITEM()
RATIONAL_B_SPLINE_CURVE((1.,0.988,1.))
REPRESENTATION_ITEM('')
);
#328=(
BOUNDED_CURVE()
B_SPLINE_CURVE(1,(#675,#676),.UNSPECIFIED.,.F.,.F.)
B_SPLINE_CURVE_WITH_KNOTS((2,2),(-16.,-3.),
 .UNSPECIFIED.)
CURVE()
GEOMETRIC_REPRESENTATION_ITEM()
RATIONAL_B_SPLINE_CURVE((1.,1.))
REPRESENTATION_ITEM('')
);
#329=(
BOUNDED_CURVE()
B_SPLINE_CURVE(1,(#677,#678),.UNSPECIFIED.,.F.,.F.)
B_SPLINE_CURVE_WITH_KNOTS((2,2),(-16.,-3.),
 .UNSPECIFIED.)
CURVE()
GEOMETRIC_REPRESENTATION_ITEM()
RATIONAL_B_SPLINE_CURVE((1.,1.))
REPRESENTATION_ITEM('')
);
#332=(
BOUNDED_CURVE()
B_SPLINE_CURVE(1,(#691,#692),.UNSPECIFIED.,.F.,.F.)
B_SPLINE_CURVE_WITH_KNOTS((2,2),(-16.,-3.),
 .UNSPECIFIED.)
CURVE()
GEOMETRIC_REPRESENTATION_ITEM()
RATIONAL_B_SPLINE_CURVE((1.,1.))
REPRESENTATION_ITEM('')
);
#333=(
BOUNDED_CURVE()
B_SPLINE_CURVE(2,(#699,#700,#701),.UNSPECIFIED.,.F.,.F.)
B_SPLINE_CURVE_WITH_KNOTS((3,3),(0.,4.594),.UNSPECIFIED.)
CURVE()
GEOMETRIC_REPRESENTATION_ITEM()
RATIONAL_B_SPLINE_CURVE((1.,0.988,1.))
REPRESENTATION_ITEM('')
);
#334=(
BOUNDED_CURVE()
B_SPLINE_CURVE(2,(#708,#709,#710),.UNSPECIFIED.,.F.,.F.)
B_SPLINE_CURVE_WITH_KNOTS((3,3),(0.,4.594),.UNSPECIFIED.)
CURVE()
GEOMETRIC_REPRESENTATION_ITEM()
RATIONAL_B_SPLINE_CURVE((1.,0.988,1.))
REPRESENTATION_ITEM('')
);
#341=(
BOUNDED_CURVE()
B_SPLINE_CURVE(1,(#746,#747),.UNSPECIFIED.,.F.,.F.)
B_SPLINE_CURVE_WITH_KNOTS((2,2),(-16.,-3.),
 .UNSPECIFIED.)
CURVE()
GEOMETRIC_REPRESENTATION_ITEM()
RATIONAL_B_SPLINE_CURVE((1.,1.))
REPRESENTATION_ITEM('')
);
#354=VERTEX_POINT('',#562);
#355=VERTEX_POINT('',#563);
#356=VERTEX_POINT('',#564);
#357=VERTEX_POINT('',#565);
#363=(
BOUNDED_SURFACE()
B_SPLINE_SURFACE(1,2,((#500,#501,#502),(#503,#504,#505)),.UNSPECIFIED.,
 .F.,.F.,.F.)
B_SPLINE_SURFACE_WITH_KNOTS((2,2),(3,3),(0.,17.5),(0.,4.594),
 .UNSPECIFIED.)
GEOMETRIC_REPRESENTATION_ITEM()
RATIONAL_B_SPLINE_SURFACE(((1.,0.988,1.),(1.,0.988,
1.)))
REPRESENTATION_ITEM('')
SURFACE()
);
#367=B_SPLINE_SURFACE_WITH_KNOTS('',1,1,((#466,#467),(#468,#469)),
 .UNSPECIFIED.,.F.,.F.,.F.,(2,2),(2,2),(-34.182,-30.091),
(0.,35.),.UNSPECIFIED.);
#368=B_SPLINE_SURFACE_WITH_KNOTS('',1,1,((#470,#471),(#472,#473)),
 .UNSPECIFIED.,.F.,.F.,.F.,(2,2),(2,2),(-30.091,-17.091),
(0.,35.),.UNSPECIFIED.);
#369=B_SPLINE_SURFACE_WITH_KNOTS('',1,1,((#474,#475),(#476,#477)),
 .UNSPECIFIED.,.F.,.F.,.F.,(2,2),(2,2),(-17.091,-13.),
(0.,35.),.UNSPECIFIED.);
#370=B_SPLINE_SURFACE_WITH_KNOTS('',1,1,((#478,#479),(#480,#481)),
 .UNSPECIFIED.,.F.,.F.,.F.,(2,2),(2,2),(-13.,0.),(0.,35.),
 .UNSPECIFIED.);
#466=CARTESIAN_POINT('',(-86.455,-8.454,6.455));
#467=CARTESIAN_POINT('',(-86.455,26.546,6.455));
#468=CARTESIAN_POINT('',(-90.545,-8.454,6.455));
#469=CARTESIAN_POINT('',(-90.545,26.546,6.455));
#470=CARTESIAN_POINT('',(-90.545,-8.454,6.455));
#471=CARTESIAN_POINT('',(-90.545,26.546,6.455));
#472=CARTESIAN_POINT('',(-90.545,-8.454,19.455));
#473=CARTESIAN_POINT('',(-90.545,26.546,19.455));
#474=CARTESIAN_POINT('',(-90.545,-8.454,19.455));
#475=CARTESIAN_POINT('',(-90.545,26.546,19.455));
#476=CARTESIAN_POINT('',(-86.455,-8.454,19.455));
#477=CARTESIAN_POINT('',(-86.455,26.546,19.455));
#478=CARTESIAN_POINT('',(-86.455,-8.454,19.455));
#479=CARTESIAN_POINT('',(-86.455,26.546,19.455));
#480=CARTESIAN_POINT('',(-86.455,-8.454,6.455));
#481=CARTESIAN_POINT('',(-86.455,26.546,6.455));
#500=CARTESIAN_POINT('',(-90.545,-5.343,22.455));
#501=CARTESIAN_POINT('',(-88.34,-4.636,22.455));
#502=CARTESIAN_POINT('',(-86.455,-3.292,22.455));
#503=CARTESIAN_POINT('',(-90.545,-5.343,4.955));
#504=CARTESIAN_POINT('',(-88.34,-4.636,4.955));
#505=CARTESIAN_POINT('',(-86.455,-3.292,4.955));
#562=CARTESIAN_POINT('',(-86.455,-3.292,6.455));
#563=CARTESIAN_POINT('',(-90.545,-5.343,6.455));
#564=CARTESIAN_POINT('',(-90.545,-5.343,19.455));
#565=CARTESIAN_POINT('',(-86.455,-3.292,19.455));
#615=CARTESIAN_POINT('',(-90.545,-5.343,19.455));
#616=CARTESIAN_POINT('',(-88.34,-4.636,19.455));
#617=CARTESIAN_POINT('',(-86.455,-3.292,19.455));
#618=CARTESIAN_POINT('',(-17.091,3.111));
#619=CARTESIAN_POINT('',(-14.885,3.817));
#620=CARTESIAN_POINT('',(-13.,5.162));
#675=CARTESIAN_POINT('',(-90.545,-5.343,6.455));
#676=CARTESIAN_POINT('',(-90.545,-5.343,19.455));
#677=CARTESIAN_POINT('',(-30.091,3.111));
#678=CARTESIAN_POINT('',(-17.091,3.111));
#691=CARTESIAN_POINT('',(-86.455,-3.292,6.455));
#692=CARTESIAN_POINT('',(-86.455,-3.292,19.455));
#693=CARTESIAN_POINT('',(16.,4.594));
#694=CARTESIAN_POINT('',(3.,4.594));
#695=CARTESIAN_POINT('',(3.,0.));
#696=CARTESIAN_POINT('',(3.,4.594));
#697=CARTESIAN_POINT('',(16.,0.));
#698=CARTESIAN_POINT('',(3.,0.));
#699=CARTESIAN_POINT('',(-90.545,-5.343,6.455));
#700=CARTESIAN_POINT('',(-88.34,-4.636,6.455));
#701=CARTESIAN_POINT('',(-86.455,-3.292,6.455));
#702=CARTESIAN_POINT('',(16.,0.));
#703=CARTESIAN_POINT('',(16.,4.594));
#708=CARTESIAN_POINT('',(-30.091,3.111));
#709=CARTESIAN_POINT('',(-32.296,3.817));
#710=CARTESIAN_POINT('',(-34.182,5.162));
#746=CARTESIAN_POINT('',(0.,5.162));
#747=CARTESIAN_POINT('',(-13.,5.162));
#763=(
GEOMETRIC_REPRESENTATION_CONTEXT(2)
PARAMETRIC_REPRESENTATION_CONTEXT()
REPRESENTATION_CONTEXT('pspace','')
);
