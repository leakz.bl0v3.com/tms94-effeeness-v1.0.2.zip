STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'MODELM~1',/* time_stamp */ '2021-06-04T15:29:32-07:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v16.5',/* originating_system */ '',/* authorisation */ '');
FILE_SCHEMA (('CONFIG_CONTROL_DESIGN'));
Length unit declared in the file: millimetre
Products named in the file (1): Document
Bounding box: 4.09 x 28.78 x 13 mm (x, y, z)
Volume: 1415.4 mm3; surface area: 1030.1 mm2
Topology: 1 solids, 1 shells, 11 faces, 27 edges, 18 vertices
Faces by surface type: bspline 11
Entity records: 708 total; most frequent: CARTESIAN_POINT 298, ORIENTED_EDGE 54, PCURVE 54, DEFINITIONAL_REPRESENTATION 54, B_SPLINE_CURVE_WITH_KNOTS 46, SURFACE_CURVE 27, EDGE_CURVE 27, VERTEX_POINT 18
