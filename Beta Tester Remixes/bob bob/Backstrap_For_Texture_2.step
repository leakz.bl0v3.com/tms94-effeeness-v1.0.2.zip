One B-rep face of a CAD part: STEP entity #1496.
In plain terms, the planar face has unit normal (0, -1, 0).
Length unit declared in the file: inch
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals, lengths and spline knots to 5 decimals):
#47=PLANE('',#1634);
#109=LINE('',#2528,#220);
#120=LINE('',#2581,#231);
#121=LINE('',#2584,#232);
#122=LINE('',#2586,#233);
#123=LINE('',#2587,#234);
#124=LINE('',#2589,#235);
#125=LINE('',#2591,#236);
#126=LINE('',#2593,#237);
#127=LINE('',#2595,#238);
#128=LINE('',#2596,#239);
#220=VECTOR('',#1853,0.3937);
#231=VECTOR('',#1900,0.3937);
#232=VECTOR('',#1903,0.3937);
#233=VECTOR('',#1904,0.035);
#234=VECTOR('',#1905,0.3937);
#235=VECTOR('',#1906,0.3937);
#236=VECTOR('',#1907,0.3937);
#237=VECTOR('',#1908,0.3937);
#238=VECTOR('',#1909,0.035);
#239=VECTOR('',#1910,0.3937);
#366=FACE_OUTER_BOUND('',#455,.T.);
#455=EDGE_LOOP('',(#1168,#1169,#1170,#1171,#1172,#1173,#1174,#1175,#1176,
#1177));
#682=VERTEX_POINT('',#2518);
#684=VERTEX_POINT('',#2524);
#696=VERTEX_POINT('',#2562);
#698=VERTEX_POINT('',#2568);
#700=VERTEX_POINT('',#2583);
#701=VERTEX_POINT('',#2585);
#702=VERTEX_POINT('',#2588);
#703=VERTEX_POINT('',#2590);
#704=VERTEX_POINT('',#2592);
#705=VERTEX_POINT('',#2594);
#854=EDGE_CURVE('',#682,#684,#109,.T.);
#876=EDGE_CURVE('',#696,#698,#120,.T.);
#877=EDGE_CURVE('',#700,#682,#121,.T.);
#878=EDGE_CURVE('',#701,#700,#122,.T.);
#879=EDGE_CURVE('',#698,#701,#123,.T.);
#880=EDGE_CURVE('',#702,#696,#124,.T.);
#881=EDGE_CURVE('',#703,#702,#125,.T.);
#882=EDGE_CURVE('',#704,#703,#126,.T.);
#883=EDGE_CURVE('',#705,#704,#127,.T.);
#884=EDGE_CURVE('',#684,#705,#128,.T.);
#1168=ORIENTED_EDGE('',*,*,#854,.F.);
#1169=ORIENTED_EDGE('',*,*,#877,.F.);
#1170=ORIENTED_EDGE('',*,*,#878,.F.);
#1171=ORIENTED_EDGE('',*,*,#879,.F.);
#1172=ORIENTED_EDGE('',*,*,#876,.F.);
#1173=ORIENTED_EDGE('',*,*,#880,.F.);
#1174=ORIENTED_EDGE('',*,*,#881,.F.);
#1175=ORIENTED_EDGE('',*,*,#882,.F.);
#1176=ORIENTED_EDGE('',*,*,#883,.F.);
#1177=ORIENTED_EDGE('',*,*,#884,.F.);
#1496=ADVANCED_FACE('',(#366),#47,.T.);
#1634=AXIS2_PLACEMENT_3D('',#2582,#1901,#1902);
#1853=DIRECTION('',(-1.,0.,0.));
#1900=DIRECTION('',(0.,0.,-1.));
#1901=DIRECTION('center_axis',(0.,-1.,0.));
#1902=DIRECTION('ref_axis',(1.,0.,0.));
#1903=DIRECTION('',(0.,0.,-1.));
#1904=DIRECTION('',(0.948,0.,-0.319));
#1905=DIRECTION('',(1.,0.,0.));
#1906=DIRECTION('',(1.,0.,0.));
#1907=DIRECTION('',(0.,0.,1.));
#1908=DIRECTION('',(1.,0.,0.));
#1909=DIRECTION('',(0.948,0.,0.319));
#1910=DIRECTION('',(0.,0.,1.));
#2518=CARTESIAN_POINT('',(0.52315,-1.575,-0.04));
#2524=CARTESIAN_POINT('',(-0.5231,-1.575,-0.04));
#2528=CARTESIAN_POINT('',(-0.22499,-1.575,-0.04));
#2562=CARTESIAN_POINT('',(0.085,-1.575,0.21219));
#2568=CARTESIAN_POINT('',(0.085,-1.575,0.185));
#2581=CARTESIAN_POINT('',(0.085,-1.575,0.215));
#2582=CARTESIAN_POINT('Origin',(-0.45,-1.575,0.));
#2583=CARTESIAN_POINT('',(0.52315,-1.575,0.11972));
#2584=CARTESIAN_POINT('',(0.52315,-1.575,0.0525));
#2585=CARTESIAN_POINT('',(0.32935,-1.575,0.185));
#2586=CARTESIAN_POINT('',(0.42159,-1.575,0.15393));
#2587=CARTESIAN_POINT('',(-0.08625,-1.575,0.185));
#2588=CARTESIAN_POINT('',(-0.085,-1.575,0.21219));
#2589=CARTESIAN_POINT('',(-0.3375,-1.575,0.21219));
#2590=CARTESIAN_POINT('',(-0.085,-1.575,0.185));
#2591=CARTESIAN_POINT('',(-0.085,-1.575,0.215));
#2592=CARTESIAN_POINT('',(-0.32937,-1.575,0.185));
#2593=CARTESIAN_POINT('',(-0.36375,-1.575,0.185));
#2594=CARTESIAN_POINT('',(-0.5231,-1.575,0.11975));
#2595=CARTESIAN_POINT('',(-0.49367,-1.575,0.12966));
#2596=CARTESIAN_POINT('',(-0.5231,-1.575,0.0525));
