STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'C:/Users/Bob/Desktop/Backstrap_Slim_1 v3.step',/* time_stamp */ '2021-06-11T13:08:18-07:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v18.1',/* originating_system */ 'Autodesk Translation Framework v10.9.0.1377',/* authorisation */ '');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 }'));
Length unit declared in the file: inch
Products named in the file (1): Backstrap_Slim_1
Bounding box: 22.86 x 80.01 x 11.71 mm (x, y, z)
Volume: 11014.1 mm3; surface area: 5532 mm2
Topology: 1 solids, 1 shells, 86 faces, 225 edges, 141 vertices
Faces by surface type: bspline 29, plane 27, cylinder 24, torus 4, cone 2
Full cylindrical faces by diameter (mm): 2.667 x1
Entity records: 3647 total; most frequent: CARTESIAN_POINT 1698, ORIENTED_EDGE 450, DIRECTION 318, EDGE_CURVE 225, VERTEX_POINT 141, AXIS2_PLACEMENT_3D 118, EDGE_LOOP 88, FACE_OUTER_BOUND 86
