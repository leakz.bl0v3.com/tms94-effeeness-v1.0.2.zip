One B-rep face of a CAD part: STEP entity #1421.
In plain terms, the planar face has unit normal (0, -1, 0).
Length unit declared in the file: inch
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals, lengths and spline knots to 5 decimals):
#72=PLANE('',#1550);
#112=B_SPLINE_CURVE_WITH_KNOTS('',3,(#2222,#2223,#2224,#2225,#2226),
 .UNSPECIFIED.,.F.,.F.,(4,1,4),(1.85023,2.18501,2.63139),
 .UNSPECIFIED.);
#113=B_SPLINE_CURVE_WITH_KNOTS('',3,(#2230,#2231,#2232,#2233,#2234),
 .UNSPECIFIED.,.F.,.F.,(4,1,4),(-0.09402,0.24076,0.68714),
 .UNSPECIFIED.);
#182=LINE('',#2012,#264);
#184=LINE('',#2028,#266);
#192=LINE('',#2110,#274);
#200=LINE('',#2191,#282);
#201=LINE('',#2199,#283);
#203=LINE('',#2220,#285);
#204=LINE('',#2227,#286);
#205=LINE('',#2229,#287);
#264=VECTOR('',#1662,0.3937);
#266=VECTOR('',#1668,0.3937);
#274=VECTOR('',#1710,0.3937);
#282=VECTOR('',#1740,0.3937);
#283=VECTOR('',#1741,0.3937);
#285=VECTOR('',#1749,0.3937);
#286=VECTOR('',#1750,0.3937);
#287=VECTOR('',#1751,0.3937);
#384=FACE_OUTER_BOUND('',#472,.T.);
#472=EDGE_LOOP('',(#1063,#1064,#1065,#1066,#1067,#1068,#1069,#1070,#1071,
#1072));
#582=VERTEX_POINT('',#1940);
#600=VERTEX_POINT('',#2011);
#602=VERTEX_POINT('',#2026);
#617=VERTEX_POINT('',#2099);
#631=VERTEX_POINT('',#2184);
#634=VERTEX_POINT('',#2189);
#635=VERTEX_POINT('',#2198);
#639=VERTEX_POINT('',#2219);
#640=VERTEX_POINT('',#2221);
#641=VERTEX_POINT('',#2228);
#745=EDGE_CURVE('',#582,#600,#182,.T.);
#749=EDGE_CURVE('',#602,#582,#184,.T.);
#772=EDGE_CURVE('',#617,#602,#192,.T.);
#793=EDGE_CURVE('',#634,#631,#200,.T.);
#794=EDGE_CURVE('',#635,#631,#201,.T.);
#799=EDGE_CURVE('',#639,#634,#203,.T.);
#800=EDGE_CURVE('',#640,#639,#112,.T.);
#801=EDGE_CURVE('',#600,#640,#204,.T.);
#802=EDGE_CURVE('',#641,#617,#205,.T.);
#803=EDGE_CURVE('',#635,#641,#113,.T.);
#1063=ORIENTED_EDGE('',*,*,#793,.F.);
#1064=ORIENTED_EDGE('',*,*,#799,.F.);
#1065=ORIENTED_EDGE('',*,*,#800,.F.);
#1066=ORIENTED_EDGE('',*,*,#801,.F.);
#1067=ORIENTED_EDGE('',*,*,#745,.F.);
#1068=ORIENTED_EDGE('',*,*,#749,.F.);
#1069=ORIENTED_EDGE('',*,*,#772,.F.);
#1070=ORIENTED_EDGE('',*,*,#802,.F.);
#1071=ORIENTED_EDGE('',*,*,#803,.F.);
#1072=ORIENTED_EDGE('',*,*,#794,.T.);
#1421=ADVANCED_FACE('',(#384),#72,.T.);
#1550=AXIS2_PLACEMENT_3D('',#2218,#1747,#1748);
#1662=DIRECTION('',(0.,0.,-1.));
#1668=DIRECTION('',(1.,0.,0.));
#1710=DIRECTION('',(0.,0.,1.));
#1740=DIRECTION('',(-1.,0.,0.));
#1741=DIRECTION('',(0.,0.,-1.));
#1747=DIRECTION('center_axis',(0.,-1.,0.));
#1748=DIRECTION('ref_axis',(1.,0.,0.));
#1749=DIRECTION('',(0.,0.,-1.));
#1750=DIRECTION('',(1.,0.,0.));
#1751=DIRECTION('',(1.,0.,0.));
#1940=CARTESIAN_POINT('',(0.085,-1.575,0.21219));
#2011=CARTESIAN_POINT('',(0.085,-1.575,0.185));
#2012=CARTESIAN_POINT('',(0.085,-1.575,0.215));
#2026=CARTESIAN_POINT('',(-0.085,-1.575,0.21219));
#2028=CARTESIAN_POINT('',(-0.3375,-1.575,0.21219));
#2099=CARTESIAN_POINT('',(-0.085,-1.575,0.185));
#2110=CARTESIAN_POINT('',(-0.085,-1.575,0.215));
#2184=CARTESIAN_POINT('',(-0.43502,-1.575,-0.04));
#2189=CARTESIAN_POINT('',(0.43502,-1.575,-0.04));
#2191=CARTESIAN_POINT('',(-0.225,-1.575,-0.04));
#2198=CARTESIAN_POINT('',(-0.43502,-1.575,-0.03897));
#2199=CARTESIAN_POINT('',(-0.43502,-1.575,0.));
#2218=CARTESIAN_POINT('Origin',(-0.45,-1.575,0.));
#2219=CARTESIAN_POINT('',(0.43502,-1.575,-0.03897));
#2220=CARTESIAN_POINT('',(0.43502,-1.575,0.));
#2221=CARTESIAN_POINT('',(0.24483,-1.575,0.185));
#2222=CARTESIAN_POINT('Ctrl Pts',(0.24483,-1.575,0.185));
#2223=CARTESIAN_POINT('Ctrl Pts',(0.28629,-1.575,0.17043));
#2224=CARTESIAN_POINT('Ctrl Pts',(0.3751,-1.575,0.11366));
#2225=CARTESIAN_POINT('Ctrl Pts',(0.42426,-1.575,0.01927));
#2226=CARTESIAN_POINT('Ctrl Pts',(0.43502,-1.575,-0.03897));
#2227=CARTESIAN_POINT('',(-0.08625,-1.575,0.185));
#2228=CARTESIAN_POINT('',(-0.24483,-1.575,0.185));
#2229=CARTESIAN_POINT('',(-0.36375,-1.575,0.185));
#2230=CARTESIAN_POINT('Ctrl Pts',(-0.43502,-1.575,
-0.03897));
#2231=CARTESIAN_POINT('Ctrl Pts',(-0.42695,-1.575,
0.00471));
#2232=CARTESIAN_POINT('Ctrl Pts',(-0.38577,-1.575,
0.10103));
#2233=CARTESIAN_POINT('Ctrl Pts',(-0.30011,-1.575,
0.16558));
#2234=CARTESIAN_POINT('Ctrl Pts',(-0.24483,-1.575,
0.185));
