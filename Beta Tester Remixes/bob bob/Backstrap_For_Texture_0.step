STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'C:/Users/Bob/Desktop/Backstrap_Corrected_2 v3.step',/* time_stamp */ '2021-06-11T12:10:50-07:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v18.1',/* originating_system */ 'Autodesk Translation Framework v10.9.0.1377',/* authorisation */ '');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 }'));
Length unit declared in the file: inch
Products named in the file (1): Backstrap_Corrected_2
Bounding box: 29.11 x 80.01 x 11.64 mm (x, y, z)
Volume: 11943.4 mm3; surface area: 5812.3 mm2
Topology: 1 solids, 1 shells, 110 faces, 290 edges, 180 vertices
Faces by surface type: plane 35, cylinder 34, bspline 33, cone 4, torus 4
Full cylindrical faces by diameter (mm): 2.667 x1
Entity records: 4422 total; most frequent: CARTESIAN_POINT 1892, ORIENTED_EDGE 576, DIRECTION 436, EDGE_CURVE 288, VERTEX_POINT 180, AXIS2_PLACEMENT_3D 160, LINE 116, VECTOR 116
