One B-rep face of a CAD part: STEP entity #1832.
In plain terms, the planar face has unit normal (0, -1, 0).
Length unit declared in the file: inch
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals, lengths and spline knots to 5 decimals):
#37=PLANE('',#1988);
#239=FACE_OUTER_BOUND('',#349,.T.);
#349=EDGE_LOOP('',(#1349,#1350,#1351,#1352,#1353,#1354,#1355,#1356,#1357,
#1358));
#445=LINE('',#2998,#561);
#456=LINE('',#3085,#572);
#458=LINE('',#3091,#574);
#466=LINE('',#3163,#582);
#468=LINE('',#3167,#584);
#469=LINE('',#3169,#585);
#470=LINE('',#3170,#586);
#471=LINE('',#3172,#587);
#472=LINE('',#3174,#588);
#473=LINE('',#3175,#589);
#561=VECTOR('',#2157,0.3937);
#572=VECTOR('',#2206,0.3937);
#574=VECTOR('',#2212,0.3937);
#582=VECTOR('',#2256,0.3937);
#584=VECTOR('',#2260,0.3937);
#585=VECTOR('',#2261,0.035);
#586=VECTOR('',#2262,0.3937);
#587=VECTOR('',#2263,0.3937);
#588=VECTOR('',#2264,0.035);
#589=VECTOR('',#2265,0.3937);
#765=VERTEX_POINT('',#2988);
#767=VERTEX_POINT('',#2994);
#783=VERTEX_POINT('',#3066);
#785=VERTEX_POINT('',#3072);
#788=VERTEX_POINT('',#3089);
#802=VERTEX_POINT('',#3152);
#803=VERTEX_POINT('',#3166);
#804=VERTEX_POINT('',#3168);
#805=VERTEX_POINT('',#3171);
#806=VERTEX_POINT('',#3173);
#963=EDGE_CURVE('',#765,#767,#445,.T.);
#988=EDGE_CURVE('',#783,#785,#456,.T.);
#991=EDGE_CURVE('',#788,#783,#458,.T.);
#1012=EDGE_CURVE('',#802,#788,#466,.T.);
#1014=EDGE_CURVE('',#803,#765,#468,.T.);
#1015=EDGE_CURVE('',#804,#803,#469,.T.);
#1016=EDGE_CURVE('',#785,#804,#470,.T.);
#1017=EDGE_CURVE('',#805,#802,#471,.T.);
#1018=EDGE_CURVE('',#806,#805,#472,.T.);
#1019=EDGE_CURVE('',#767,#806,#473,.T.);
#1349=ORIENTED_EDGE('',*,*,#963,.F.);
#1350=ORIENTED_EDGE('',*,*,#1014,.F.);
#1351=ORIENTED_EDGE('',*,*,#1015,.F.);
#1352=ORIENTED_EDGE('',*,*,#1016,.F.);
#1353=ORIENTED_EDGE('',*,*,#988,.F.);
#1354=ORIENTED_EDGE('',*,*,#991,.F.);
#1355=ORIENTED_EDGE('',*,*,#1012,.F.);
#1356=ORIENTED_EDGE('',*,*,#1017,.F.);
#1357=ORIENTED_EDGE('',*,*,#1018,.F.);
#1358=ORIENTED_EDGE('',*,*,#1019,.F.);
#1832=ADVANCED_FACE('',(#239),#37,.T.);
#1988=AXIS2_PLACEMENT_3D('',#3165,#2258,#2259);
#2157=DIRECTION('',(-1.,0.,0.));
#2206=DIRECTION('',(0.,0.,-1.));
#2212=DIRECTION('',(1.,0.,0.));
#2256=DIRECTION('',(0.,0.,1.));
#2258=DIRECTION('center_axis',(0.,-1.,0.));
#2259=DIRECTION('ref_axis',(1.,0.,0.));
#2260=DIRECTION('',(0.,0.,-1.));
#2261=DIRECTION('',(0.948,0.,-0.319));
#2262=DIRECTION('',(1.,0.,0.));
#2263=DIRECTION('',(1.,0.,0.));
#2264=DIRECTION('',(0.948,0.,0.319));
#2265=DIRECTION('',(0.,0.,1.));
#2988=CARTESIAN_POINT('',(0.52315,-1.575,-0.04));
#2994=CARTESIAN_POINT('',(-0.5231,-1.575,-0.04));
#2998=CARTESIAN_POINT('',(-0.22499,-1.575,-0.04));
#3066=CARTESIAN_POINT('',(0.085,-1.575,0.21219));
#3072=CARTESIAN_POINT('',(0.085,-1.575,0.185));
#3085=CARTESIAN_POINT('',(0.085,-1.575,0.215));
#3089=CARTESIAN_POINT('',(-0.085,-1.575,0.21219));
#3091=CARTESIAN_POINT('',(-0.3375,-1.575,0.21219));
#3152=CARTESIAN_POINT('',(-0.085,-1.575,0.185));
#3163=CARTESIAN_POINT('',(-0.085,-1.575,0.215));
#3165=CARTESIAN_POINT('Origin',(-0.45,-1.575,0.));
#3166=CARTESIAN_POINT('',(0.52315,-1.575,0.11972));
#3167=CARTESIAN_POINT('',(0.52315,-1.575,0.0525));
#3168=CARTESIAN_POINT('',(0.32935,-1.575,0.185));
#3169=CARTESIAN_POINT('',(0.42159,-1.575,0.15393));
#3170=CARTESIAN_POINT('',(-0.08625,-1.575,0.185));
#3171=CARTESIAN_POINT('',(-0.32937,-1.575,0.185));
#3172=CARTESIAN_POINT('',(-0.36375,-1.575,0.185));
#3173=CARTESIAN_POINT('',(-0.5231,-1.575,0.11975));
#3174=CARTESIAN_POINT('',(-0.49367,-1.575,0.12966));
#3175=CARTESIAN_POINT('',(-0.5231,-1.575,0.0525));
