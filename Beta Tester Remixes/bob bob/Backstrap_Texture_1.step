One B-rep face of a CAD part: STEP entity #22387.
In plain terms, the planar face has unit normal (0, -1, 0).
Length unit declared in the file: inch
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals, lengths and spline knots to 5 decimals):
#1633=FACE_OUTER_BOUND('',#3043,.T.);
#3043=EDGE_LOOP('',(#19696,#19697,#19698,#19699,#19700,#19701,#19702,#19703));
#5165=LINE('',#38930,#7289);
#5166=LINE('',#38945,#7290);
#5167=LINE('',#38947,#7291);
#5168=LINE('',#38949,#7292);
#5169=LINE('',#38950,#7293);
#5170=LINE('',#38951,#7294);
#7289=VECTOR('',#28835,0.3937);
#7290=VECTOR('',#28840,0.3937);
#7291=VECTOR('',#28841,0.3937);
#7292=VECTOR('',#28842,0.3937);
#7293=VECTOR('',#28843,0.3937);
#7294=VECTOR('',#28844,0.3937);
#7442=B_SPLINE_CURVE_WITH_KNOTS('',3,(#30455,#30456,#30457,#30458,#30459,
#30460,#30461,#30462,#30463,#30464,#30465,#30466,#30467,#30468),
 .UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,4),(-1.06424,-0.99256,
-0.82489,-0.65721,-0.49196,-0.32672,
-0.29666),.UNSPECIFIED.);
#7947=B_SPLINE_CURVE_WITH_KNOTS('',3,(#34642,#34643,#34644,#34645,#34646,
#34647,#34648,#34649,#34650,#34651,#34652,#34653,#34654,#34655),
 .UNSPECIFIED.,.F.,.F.,(4,2,2,2,2,2,4),(0.29666,0.32672,
0.49196,0.65721,0.82489,0.99256,
1.06424),.UNSPECIFIED.);
#8633=VERTEX_POINT('',#30449);
#8634=VERTEX_POINT('',#30454);
#9378=VERTEX_POINT('',#34618);
#9379=VERTEX_POINT('',#34641);
#10226=VERTEX_POINT('',#38929);
#10228=VERTEX_POINT('',#38944);
#10229=VERTEX_POINT('',#38946);
#10230=VERTEX_POINT('',#38948);
#10774=EDGE_CURVE('',#8633,#8634,#7442,.T.);
#11834=EDGE_CURVE('',#9378,#9379,#7947,.T.);
#13398=EDGE_CURVE('',#8634,#10226,#5165,.T.);
#13401=EDGE_CURVE('',#10228,#9378,#5166,.T.);
#13402=EDGE_CURVE('',#10229,#10228,#5167,.T.);
#13403=EDGE_CURVE('',#10230,#10229,#5168,.T.);
#13404=EDGE_CURVE('',#10226,#10230,#5169,.T.);
#13405=EDGE_CURVE('',#9379,#8633,#5170,.T.);
#19696=ORIENTED_EDGE('',*,*,#11834,.F.);
#19697=ORIENTED_EDGE('',*,*,#13401,.F.);
#19698=ORIENTED_EDGE('',*,*,#13402,.F.);
#19699=ORIENTED_EDGE('',*,*,#13403,.F.);
#19700=ORIENTED_EDGE('',*,*,#13404,.F.);
#19701=ORIENTED_EDGE('',*,*,#13398,.F.);
#19702=ORIENTED_EDGE('',*,*,#10774,.F.);
#19703=ORIENTED_EDGE('',*,*,#13405,.F.);
#21109=PLANE('',#23860);
#22387=ADVANCED_FACE('',(#1633),#21109,.T.);
#23860=AXIS2_PLACEMENT_3D('',#38943,#28838,#28839);
#28835=DIRECTION('',(1.,0.,0.));
#28838=DIRECTION('center_axis',(0.,-1.,0.));
#28839=DIRECTION('ref_axis',(1.,0.,0.));
#28840=DIRECTION('',(1.,0.,0.));
#28841=DIRECTION('',(0.,0.,-1.));
#28842=DIRECTION('',(1.,0.,0.));
#28843=DIRECTION('',(0.,0.,1.));
#28844=DIRECTION('',(-1.,0.,0.));
#30449=CARTESIAN_POINT('',(-0.43281,-1.575,-0.04));
#30454=CARTESIAN_POINT('',(-0.22168,-1.575,0.185));
#30455=CARTESIAN_POINT('Ctrl Pts',(-0.43281,-1.575,
-0.04));
#30456=CARTESIAN_POINT('Ctrl Pts',(-0.42979,-1.575,
-0.03049));
#30457=CARTESIAN_POINT('Ctrl Pts',(-0.42643,-1.575,
-0.0213));
#30458=CARTESIAN_POINT('Ctrl Pts',(-0.41455,-1.575,
0.00778));
#30459=CARTESIAN_POINT('Ctrl Pts',(-0.40349,-1.575,0.02922));
#30460=CARTESIAN_POINT('Ctrl Pts',(-0.37711,-1.575,
0.06932));
#30461=CARTESIAN_POINT('Ctrl Pts',(-0.36179,-1.575,
0.08796));
#30462=CARTESIAN_POINT('Ctrl Pts',(-0.33111,-1.575,
0.11907));
#30463=CARTESIAN_POINT('Ctrl Pts',(-0.31297,-1.575,
0.13444));
#30464=CARTESIAN_POINT('Ctrl Pts',(-0.27383,-1.575,
0.16098));
#30465=CARTESIAN_POINT('Ctrl Pts',(-0.25284,-1.575,
0.17215));
#30466=CARTESIAN_POINT('Ctrl Pts',(-0.22921,-1.575,
0.18207));
#30467=CARTESIAN_POINT('Ctrl Pts',(-0.22548,-1.575,
0.18356));
#30468=CARTESIAN_POINT('Ctrl Pts',(-0.22168,-1.575,
0.185));
#34618=CARTESIAN_POINT('',(0.22168,-1.575,0.185));
#34641=CARTESIAN_POINT('',(0.43281,-1.575,-0.04));
#34642=CARTESIAN_POINT('Ctrl Pts',(0.22168,-1.575,
0.185));
#34643=CARTESIAN_POINT('Ctrl Pts',(0.22548,-1.575,
0.18356));
#34644=CARTESIAN_POINT('Ctrl Pts',(0.22921,-1.575,
0.18207));
#34645=CARTESIAN_POINT('Ctrl Pts',(0.25284,-1.575,
0.17215));
#34646=CARTESIAN_POINT('Ctrl Pts',(0.27383,-1.575,0.16098));
#34647=CARTESIAN_POINT('Ctrl Pts',(0.31297,-1.575,
0.13444));
#34648=CARTESIAN_POINT('Ctrl Pts',(0.33111,-1.575,
0.11907));
#34649=CARTESIAN_POINT('Ctrl Pts',(0.36179,-1.575,
0.08796));
#34650=CARTESIAN_POINT('Ctrl Pts',(0.37711,-1.575,
0.06932));
#34651=CARTESIAN_POINT('Ctrl Pts',(0.40349,-1.575,
0.02922));
#34652=CARTESIAN_POINT('Ctrl Pts',(0.41455,-1.575,
0.00778));
#34653=CARTESIAN_POINT('Ctrl Pts',(0.42643,-1.575,
-0.0213));
#34654=CARTESIAN_POINT('Ctrl Pts',(0.42979,-1.575,
-0.03049));
#34655=CARTESIAN_POINT('Ctrl Pts',(0.43281,-1.575,-0.04));
#38929=CARTESIAN_POINT('',(-0.085,-1.575,0.185));
#38930=CARTESIAN_POINT('',(-0.36375,-1.575,0.185));
#38943=CARTESIAN_POINT('Origin',(-0.45,-1.575,0.));
#38944=CARTESIAN_POINT('',(0.085,-1.575,0.185));
#38945=CARTESIAN_POINT('',(-0.08625,-1.575,0.185));
#38946=CARTESIAN_POINT('',(0.085,-1.575,0.21219));
#38947=CARTESIAN_POINT('',(0.085,-1.575,0.215));
#38948=CARTESIAN_POINT('',(-0.085,-1.575,0.21219));
#38949=CARTESIAN_POINT('',(-0.3375,-1.575,0.21219));
#38950=CARTESIAN_POINT('',(-0.085,-1.575,0.215));
#38951=CARTESIAN_POINT('',(-0.22499,-1.575,-0.04));
