STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'C:/Users/Bob/Desktop/Gun_Stuff/Printables/Invisiboogle6.2.21.2/Invisiboogle/Invisibinary/STL/Backstrap_For_Texture_Slim_2 v4.step',/* time_stamp */ '2021-06-11T11:08:02-07:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v18.1',/* originating_system */ 'Autodesk Translation Framework v10.9.0.1377',/* authorisation */ '');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 }'));
Length unit declared in the file: inch
Products named in the file (1): Backstrap_For_Texture_Slim_2
Bounding box: 23.71 x 80.01 x 12.14 mm (x, y, z)
Volume: 9910 mm3; surface area: 5803 mm2
Topology: 1 solids, 1 shells, 1298 faces, 3211 edges, 2027 vertices
Faces by surface type: plane 1235, torus 40, cylinder 20, cone 2, bspline 1
Full cylindrical faces by diameter (mm): 2.667 x1
Entity records: 39186 total; most frequent: CARTESIAN_POINT 10154, ORIENTED_EDGE 6422, DIRECTION 5090, EDGE_CURVE 3211, LINE 2124, VECTOR 2124, VERTEX_POINT 2027, AXIS2_PLACEMENT_3D 1483
