One B-rep face of a CAD part: STEP entity #1011.
In plain terms, the planar face has unit normal (0, -1, 0).
Length unit declared in the file: inch
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals, lengths and spline knots to 5 decimals):
#31=PLANE('',#1103);
#81=LINE('',#1869,#154);
#82=LINE('',#1884,#155);
#83=LINE('',#1886,#156);
#84=LINE('',#1888,#157);
#85=LINE('',#1889,#158);
#86=LINE('',#1890,#159);
#154=VECTOR('',#1276,0.3937);
#155=VECTOR('',#1281,0.3937);
#156=VECTOR('',#1282,0.3937);
#157=VECTOR('',#1283,0.3937);
#158=VECTOR('',#1284,0.3937);
#159=VECTOR('',#1285,0.3937);
#242=FACE_OUTER_BOUND('',#301,.T.);
#301=EDGE_LOOP('',(#793,#794,#795,#796,#797,#798,#799,#800));
#389=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1562,#1563,#1564,#1565,#1566,#1567,
#1568,#1569,#1570,#1571,#1572,#1573,#1574,#1575),.UNSPECIFIED.,.F.,.F.,
(4,2,2,2,2,2,4),(0.29666,0.32672,0.49196,
0.65721,0.82489,0.99256,1.06424),
 .UNSPECIFIED.);
#402=B_SPLINE_CURVE_WITH_KNOTS('',3,(#1741,#1742,#1743,#1744,#1745,#1746,
#1747,#1748,#1749,#1750,#1751,#1752,#1753,#1754),.UNSPECIFIED.,.F.,.F.,
(4,2,2,2,2,2,4),(-1.06424,-0.99256,-0.82489,
-0.65721,-0.49196,-0.32672,-0.29666),
 .UNSPECIFIED.);
#429=VERTEX_POINT('',#1538);
#430=VERTEX_POINT('',#1561);
#465=VERTEX_POINT('',#1735);
#466=VERTEX_POINT('',#1740);
#479=VERTEX_POINT('',#1868);
#481=VERTEX_POINT('',#1883);
#482=VERTEX_POINT('',#1885);
#483=VERTEX_POINT('',#1887);
#528=EDGE_CURVE('',#429,#430,#389,.T.);
#576=EDGE_CURVE('',#465,#466,#402,.T.);
#597=EDGE_CURVE('',#466,#479,#81,.T.);
#600=EDGE_CURVE('',#481,#429,#82,.T.);
#601=EDGE_CURVE('',#482,#481,#83,.T.);
#602=EDGE_CURVE('',#483,#482,#84,.T.);
#603=EDGE_CURVE('',#479,#483,#85,.T.);
#604=EDGE_CURVE('',#430,#465,#86,.T.);
#793=ORIENTED_EDGE('',*,*,#528,.F.);
#794=ORIENTED_EDGE('',*,*,#600,.F.);
#795=ORIENTED_EDGE('',*,*,#601,.F.);
#796=ORIENTED_EDGE('',*,*,#602,.F.);
#797=ORIENTED_EDGE('',*,*,#603,.F.);
#798=ORIENTED_EDGE('',*,*,#597,.F.);
#799=ORIENTED_EDGE('',*,*,#576,.F.);
#800=ORIENTED_EDGE('',*,*,#604,.F.);
#1011=ADVANCED_FACE('',(#242),#31,.T.);
#1103=AXIS2_PLACEMENT_3D('',#1882,#1279,#1280);
#1276=DIRECTION('',(1.,0.,0.));
#1279=DIRECTION('center_axis',(0.,-1.,0.));
#1280=DIRECTION('ref_axis',(1.,0.,0.));
#1281=DIRECTION('',(1.,0.,0.));
#1282=DIRECTION('',(0.,0.,-1.));
#1283=DIRECTION('',(1.,0.,0.));
#1284=DIRECTION('',(0.,0.,1.));
#1285=DIRECTION('',(-1.,0.,0.));
#1538=CARTESIAN_POINT('',(0.22168,-1.575,0.185));
#1561=CARTESIAN_POINT('',(0.43281,-1.575,-0.04));
#1562=CARTESIAN_POINT('Ctrl Pts',(0.22168,-1.575,0.185));
#1563=CARTESIAN_POINT('Ctrl Pts',(0.22548,-1.575,0.18356));
#1564=CARTESIAN_POINT('Ctrl Pts',(0.22921,-1.575,0.18207));
#1565=CARTESIAN_POINT('Ctrl Pts',(0.25284,-1.575,0.17215));
#1566=CARTESIAN_POINT('Ctrl Pts',(0.27383,-1.575,0.16098));
#1567=CARTESIAN_POINT('Ctrl Pts',(0.31297,-1.575,0.13444));
#1568=CARTESIAN_POINT('Ctrl Pts',(0.33111,-1.575,0.11907));
#1569=CARTESIAN_POINT('Ctrl Pts',(0.36179,-1.575,0.08796));
#1570=CARTESIAN_POINT('Ctrl Pts',(0.37711,-1.575,0.06932));
#1571=CARTESIAN_POINT('Ctrl Pts',(0.40349,-1.575,0.02922));
#1572=CARTESIAN_POINT('Ctrl Pts',(0.41455,-1.575,0.00778));
#1573=CARTESIAN_POINT('Ctrl Pts',(0.42643,-1.575,-0.0213));
#1574=CARTESIAN_POINT('Ctrl Pts',(0.42979,-1.575,-0.03049));
#1575=CARTESIAN_POINT('Ctrl Pts',(0.43281,-1.575,-0.04));
#1735=CARTESIAN_POINT('',(-0.43281,-1.575,-0.04));
#1740=CARTESIAN_POINT('',(-0.22168,-1.575,0.185));
#1741=CARTESIAN_POINT('Ctrl Pts',(-0.43281,-1.575,
-0.04));
#1742=CARTESIAN_POINT('Ctrl Pts',(-0.42979,-1.575,
-0.03049));
#1743=CARTESIAN_POINT('Ctrl Pts',(-0.42643,-1.575,
-0.0213));
#1744=CARTESIAN_POINT('Ctrl Pts',(-0.41455,-1.575,
0.00778));
#1745=CARTESIAN_POINT('Ctrl Pts',(-0.40349,-1.575,0.02922));
#1746=CARTESIAN_POINT('Ctrl Pts',(-0.37711,-1.575,
0.06932));
#1747=CARTESIAN_POINT('Ctrl Pts',(-0.36179,-1.575,
0.08796));
#1748=CARTESIAN_POINT('Ctrl Pts',(-0.33111,-1.575,
0.11907));
#1749=CARTESIAN_POINT('Ctrl Pts',(-0.31297,-1.575,
0.13444));
#1750=CARTESIAN_POINT('Ctrl Pts',(-0.27383,-1.575,
0.16098));
#1751=CARTESIAN_POINT('Ctrl Pts',(-0.25284,-1.575,
0.17215));
#1752=CARTESIAN_POINT('Ctrl Pts',(-0.22921,-1.575,
0.18207));
#1753=CARTESIAN_POINT('Ctrl Pts',(-0.22548,-1.575,
0.18356));
#1754=CARTESIAN_POINT('Ctrl Pts',(-0.22168,-1.575,
0.185));
#1868=CARTESIAN_POINT('',(-0.085,-1.575,0.185));
#1869=CARTESIAN_POINT('',(-0.36375,-1.575,0.185));
#1882=CARTESIAN_POINT('Origin',(-0.45,-1.575,0.));
#1883=CARTESIAN_POINT('',(0.085,-1.575,0.185));
#1884=CARTESIAN_POINT('',(-0.08625,-1.575,0.185));
#1885=CARTESIAN_POINT('',(0.085,-1.575,0.21219));
#1886=CARTESIAN_POINT('',(0.085,-1.575,0.215));
#1887=CARTESIAN_POINT('',(-0.085,-1.575,0.21219));
#1888=CARTESIAN_POINT('',(-0.3375,-1.575,0.21219));
#1889=CARTESIAN_POINT('',(-0.085,-1.575,0.215));
#1890=CARTESIAN_POINT('',(-0.22499,-1.575,-0.04));
