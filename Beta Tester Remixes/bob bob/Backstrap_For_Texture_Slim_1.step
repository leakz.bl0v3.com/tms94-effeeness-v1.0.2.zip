STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'C:/Users/Bob/Desktop/Backstrap_For_Texture_Slim_1 v2.step',/* time_stamp */ '2021-06-11T12:54:05-07:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v18.1',/* originating_system */ 'Autodesk Translation Framework v10.9.0.1377',/* authorisation */ '');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 }'));
Length unit declared in the file: inch
Products named in the file (1): Backstrap_For_Texture_Slim_1
Bounding box: 22.86 x 80.01 x 10.87 mm (x, y, z)
Volume: 9518.9 mm3; surface area: 5334.9 mm2
Topology: 1 solids, 1 shells, 59 faces, 156 edges, 99 vertices
Faces by surface type: plane 28, cylinder 20, torus 8, cone 2, bspline 1
Full cylindrical faces by diameter (mm): 2.667 x1
Entity records: 2127 total; most frequent: CARTESIAN_POINT 662, ORIENTED_EDGE 312, DIRECTION 281, EDGE_CURVE 156, AXIS2_PLACEMENT_3D 104, VERTEX_POINT 99, LINE 73, VECTOR 73
