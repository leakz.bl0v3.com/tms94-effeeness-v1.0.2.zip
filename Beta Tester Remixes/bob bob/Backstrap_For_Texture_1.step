STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'C:/Users/Bob/Desktop/Gun_Stuff/Printables/Invisiboogle6.2.21.2/Invisiboogle/Invisibinary/STL/Backstrap_For_Texture_1 v2.step',/* time_stamp */ '2021-06-11T10:59:22-07:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v18.1',/* originating_system */ 'Autodesk Translation Framework v10.9.0.1377',/* authorisation */ '');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 }'));
Length unit declared in the file: inch
Products named in the file (1): Backstrap_For_Texture_1
Bounding box: 29.11 x 80.01 x 10.87 mm (x, y, z)
Volume: 10979.1 mm3; surface area: 5726.3 mm2
Topology: 1 solids, 1 shells, 89 faces, 232 edges, 143 vertices
Faces by surface type: plane 34, cylinder 30, bspline 13, torus 8, cone 4
Full cylindrical faces by diameter (mm): 2.667 x1
Entity records: 3300 total; most frequent: CARTESIAN_POINT 1184, ORIENTED_EDGE 460, DIRECTION 395, EDGE_CURVE 230, VERTEX_POINT 143, AXIS2_PLACEMENT_3D 142, LINE 111, VECTOR 111
