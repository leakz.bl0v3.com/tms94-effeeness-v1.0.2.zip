STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'C:/Users/Green/Downloads/fns 40/STEP_FNS-940-GJSv2.1.step',/* time_stamp */ '2021-05-30T22:37:11-04:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v18.1',/* originating_system */ 'Autodesk Translation Framework v10.9.0.1377',/* authorisation */ '');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (2): STEP_FNS-940-GJSv2.1; Main Frame
Assembly tree (1 placements, depth 2):
  STEP_FNS-940-GJSv2.1
    Main Frame
Bounding box: 184.47 x 110.97 x 30 mm (x, y, z)
Volume: 86188.7 mm3; surface area: 48933.2 mm2
Topology: 14 solids, 14 shells, 1992 faces, 5550 edges, 3602 vertices
Faces by surface type: plane 1292, bspline 479, cylinder 180, torus 37, cone 4
Full cylindrical faces by diameter (mm): 2.5 x2, 3 x2, 4.1 x2
Entity records: 67376 total; most frequent: CARTESIAN_POINT 20476, ORIENTED_EDGE 11094, DIRECTION 8125, EDGE_CURVE 5547, LINE 3993, VECTOR 3993, VERTEX_POINT 3602, AXIS2_PLACEMENT_3D 2066
