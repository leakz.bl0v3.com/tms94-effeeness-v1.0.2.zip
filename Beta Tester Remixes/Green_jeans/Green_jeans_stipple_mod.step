One B-rep face of a CAD part: STEP entity #37556.
In plain terms, the toroidal (fillet/blend) face has major radius 27.537 mm and minor radius 12.5 mm.
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#1343=TOROIDAL_SURFACE('',#39660,27.537,12.5);
#4470=FACE_OUTER_BOUND('',#6496,.T.);
#6496=EDGE_LOOP('',(#33912,#33913,#33914,#33915));
#14996=B_SPLINE_CURVE_WITH_KNOTS('',3,(#66040,#66041,#66042,#66043,#66044,
#66045,#66046,#66047,#66048,#66049,#66050,#66051,#66052,#66053,#66054,#66055,
#66056,#66057,#66058,#66059,#66060,#66061,#66062,#66063,#66064,#66065,#66066,
#66067,#66068,#66069,#66070,#66071,#66072,#66073,#66074,#66075,#66076,#66077,
#66078,#66079,#66080,#66081,#66082,#66083,#66084,#66085,#66086,#66087,#66088,
#66089,#66090,#66091),.UNSPECIFIED.,.F.,.F.,(4,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,4),(-0.008,0.,0.131,0.314,
0.448,0.497,0.627,0.806,
0.94,0.985,1.115,1.294,1.429,
1.473,1.604,1.783,1.915,1.961),
 .UNSPECIFIED.);
#15270=CIRCLE('',#38904,27.537);
#15422=CIRCLE('',#39661,12.5);
#15423=CIRCLE('',#39662,15.037);
#15889=VERTEX_POINT('',#51426);
#17149=VERTEX_POINT('',#57771);
#17150=VERTEX_POINT('',#57773);
#18578=VERTEX_POINT('',#66023);
#21628=EDGE_CURVE('',#17150,#17149,#15270,.T.);
#23819=EDGE_CURVE('',#17150,#18578,#14996,.T.);
#23847=EDGE_CURVE('',#15889,#17149,#15422,.T.);
#23848=EDGE_CURVE('',#15889,#18578,#15423,.T.);
#33912=ORIENTED_EDGE('',*,*,#21628,.T.);
#33913=ORIENTED_EDGE('',*,*,#23847,.F.);
#33914=ORIENTED_EDGE('',*,*,#23848,.T.);
#33915=ORIENTED_EDGE('',*,*,#23819,.F.);
#37556=ADVANCED_FACE('',(#4470),#1343,.T.);
#38904=AXIS2_PLACEMENT_3D('',#57774,#43754,#43755);
#39660=AXIS2_PLACEMENT_3D('',#66186,#46890,#46891);
#39661=AXIS2_PLACEMENT_3D('',#66187,#46892,#46893);
#39662=AXIS2_PLACEMENT_3D('',#66188,#46894,#46895);
#43754=DIRECTION('center_axis',(0.,0.,-1.));
#43755=DIRECTION('ref_axis',(0.93,0.368,0.));
#46890=DIRECTION('center_axis',(0.,0.,1.));
#46891=DIRECTION('ref_axis',(1.,0.,0.));
#46892=DIRECTION('center_axis',(-0.309,-0.951,0.));
#46893=DIRECTION('ref_axis',(-0.951,0.309,0.));
#46894=DIRECTION('center_axis',(0.,0.,1.));
#46895=DIRECTION('ref_axis',(0.93,0.368,0.));
#51426=CARTESIAN_POINT('',(-66.022,17.2,-21.5));
#57771=CARTESIAN_POINT('',(-54.134,13.337,-34.));
#57773=CARTESIAN_POINT('',(-66.871,45.874,-34.));
#57774=CARTESIAN_POINT('Origin',(-80.324,21.847,-34.));
#66023=CARTESIAN_POINT('',(-73.077,35.023,-21.5));
#66040=CARTESIAN_POINT('Ctrl Pts',(-66.871,45.874,-34.));
#66041=CARTESIAN_POINT('Ctrl Pts',(-66.885,45.85,-34.));
#66042=CARTESIAN_POINT('Ctrl Pts',(-66.899,45.826,-34.));
#66043=CARTESIAN_POINT('Ctrl Pts',(-66.912,45.802,-34.));
#66044=CARTESIAN_POINT('Ctrl Pts',(-67.129,45.424,-33.997));
#66045=CARTESIAN_POINT('Ctrl Pts',(-67.344,45.047,-33.971));
#66046=CARTESIAN_POINT('Ctrl Pts',(-67.559,44.672,-33.923));
#66047=CARTESIAN_POINT('Ctrl Pts',(-67.858,44.148,-33.856));
#66048=CARTESIAN_POINT('Ctrl Pts',(-68.155,43.629,-33.745));
#66049=CARTESIAN_POINT('Ctrl Pts',(-68.446,43.119,-33.59));
#66050=CARTESIAN_POINT('Ctrl Pts',(-68.661,42.744,-33.477));
#66051=CARTESIAN_POINT('Ctrl Pts',(-68.873,42.374,-33.34));
#66052=CARTESIAN_POINT('Ctrl Pts',(-69.08,42.01,-33.181));
#66053=CARTESIAN_POINT('Ctrl Pts',(-69.155,41.88,-33.124));
#66054=CARTESIAN_POINT('Ctrl Pts',(-69.229,41.751,-33.064));
#66055=CARTESIAN_POINT('Ctrl Pts',(-69.302,41.622,-33.001));
#66056=CARTESIAN_POINT('Ctrl Pts',(-69.501,41.275,-32.83));
#66057=CARTESIAN_POINT('Ctrl Pts',(-69.695,40.936,-32.639));
#66058=CARTESIAN_POINT('Ctrl Pts',(-69.883,40.607,-32.429));
#66059=CARTESIAN_POINT('Ctrl Pts',(-70.141,40.156,-32.14));
#66060=CARTESIAN_POINT('Ctrl Pts',(-70.388,39.724,-31.815));
#66061=CARTESIAN_POINT('Ctrl Pts',(-70.623,39.313,-31.456));
#66062=CARTESIAN_POINT('Ctrl Pts',(-70.799,39.005,-31.187));
#66063=CARTESIAN_POINT('Ctrl Pts',(-70.969,38.709,-30.898));
#66064=CARTESIAN_POINT('Ctrl Pts',(-71.13,38.427,-30.591));
#66065=CARTESIAN_POINT('Ctrl Pts',(-71.184,38.333,-30.489));
#66066=CARTESIAN_POINT('Ctrl Pts',(-71.236,38.241,-30.386));
#66067=CARTESIAN_POINT('Ctrl Pts',(-71.288,38.15,-30.28));
#66068=CARTESIAN_POINT('Ctrl Pts',(-71.44,37.885,-29.971));
#66069=CARTESIAN_POINT('Ctrl Pts',(-71.583,37.635,-29.646));
#66070=CARTESIAN_POINT('Ctrl Pts',(-71.717,37.4,-29.308));
#66071=CARTESIAN_POINT('Ctrl Pts',(-71.901,37.078,-28.844));
#66072=CARTESIAN_POINT('Ctrl Pts',(-72.069,36.785,-28.354));
#66073=CARTESIAN_POINT('Ctrl Pts',(-72.219,36.523,-27.842));
#66074=CARTESIAN_POINT('Ctrl Pts',(-72.332,36.326,-27.456));
#66075=CARTESIAN_POINT('Ctrl Pts',(-72.435,36.146,-27.057));
#66076=CARTESIAN_POINT('Ctrl Pts',(-72.527,35.985,-26.647));
#66077=CARTESIAN_POINT('Ctrl Pts',(-72.556,35.933,-26.514));
#66078=CARTESIAN_POINT('Ctrl Pts',(-72.585,35.883,-26.38));
#66079=CARTESIAN_POINT('Ctrl Pts',(-72.613,35.835,-26.245));
#66080=CARTESIAN_POINT('Ctrl Pts',(-72.695,35.691,-25.841));
#66081=CARTESIAN_POINT('Ctrl Pts',(-72.767,35.566,-25.429));
#66082=CARTESIAN_POINT('Ctrl Pts',(-72.827,35.46,-25.012));
#66083=CARTESIAN_POINT('Ctrl Pts',(-72.91,35.315,-24.443));
#66084=CARTESIAN_POINT('Ctrl Pts',(-72.973,35.206,-23.862));
#66085=CARTESIAN_POINT('Ctrl Pts',(-73.014,35.133,-23.276));
#66086=CARTESIAN_POINT('Ctrl Pts',(-73.045,35.079,-22.84));
#66087=CARTESIAN_POINT('Ctrl Pts',(-73.065,35.044,-22.402));
#66088=CARTESIAN_POINT('Ctrl Pts',(-73.073,35.03,-21.961));
#66089=CARTESIAN_POINT('Ctrl Pts',(-73.076,35.025,-21.808));
#66090=CARTESIAN_POINT('Ctrl Pts',(-73.077,35.023,-21.654));
#66091=CARTESIAN_POINT('Ctrl Pts',(-73.077,35.023,-21.5));
#66186=CARTESIAN_POINT('Origin',(-80.324,21.847,-21.5));
#66187=CARTESIAN_POINT('Origin',(-54.134,13.337,-21.5));
#66188=CARTESIAN_POINT('Origin',(-80.324,21.847,-21.5));
